* SPICE3 file created from inverter.ext - technology: sky130A

X0 out in vdd vdd sky130_fd_pr__pfet_01v8 ad=2.75 pd=11.1 as=2.75 ps=11.1 w=5 l=0.15
X1 out in vss vss sky130_fd_pr__nfet_01v8 ad=1.1 pd=5.1 as=1.1 ps=5.1 w=2 l=0.15
C0 vdd vss 2.41725f **FLOATING
